	AREA LED, CODE, READONLY
	ENTRY
LED_START
	MOV R3,#0x1	
LOOP

	LDR R0,=0XE0200280
	MOV R1,R3
	STR R1,[R0]
	
	LDR R0,=0XE0200284
	MOV R1,#0x0
	STR R1,[R0]
	
	BL DELAY
	MOV R1,#0xf
	STR R1,[R0]
	
	BL DELAY
	
	CMP R3,#0X1000
	MOVEQ R3,#0x1
	MOVNE R3,R3,LSL#4
	B LOOP
	
DELAY
	LDR R2,=0XFFFFFFF
LOOP2
	SUBS R2,R2,#1    
	BNE LOOP2
	MOV PC,LR
	
	END