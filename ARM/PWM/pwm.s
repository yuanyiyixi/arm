	AREA PWM,CODE,READONLY
	ENTRY
START

	LDR R0,=0XE0200C40
	MOV R1,#0X0
	STR R1,[R0]
	
	LDR R0,=0XE0200C44
	LDR R1,[R0]
	
	TST R1,#0X1
	
	BEQ BUZZER
	
	B START
	
BUZZER
	LDR R0,=0XE02000A0
	MOV R1,#0X1
	STR R1,[R0]
	
	LDR R0,=0XE02000A4
	MOV R1,#0X1
	STR R1,[R0]
	
	BL DELAY
	
	MOV R1,#0X0
	STR R1,[R0]
	
	BL DELAY
	
	B START
	
DELAY
	LDR R2,=0XFFFFF
LOOP2
	SUBS R2,R2,#1    
	BNE LOOP2
	MOV PC,LR
	
	END